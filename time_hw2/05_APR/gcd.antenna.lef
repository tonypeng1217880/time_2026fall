

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO gcd 
  PIN clk_in 
    ANTENNAPARTIALMETALAREA 20.1768 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.14538 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.356 LAYER M3 ; 
    ANTENNAMAXAREACAR 38.3942 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 0.297688 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.0169 LAYER VIA3 ;
    ANTENNAMAXCUTCAR 0.957732 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 4.4618 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.03201 LAYER M4 ;
    ANTENNAGATEAREA 3.416 LAYER M4 ; 
    ANTENNAMAXAREACAR 39.7003 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 0.307058 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.957732 LAYER VIA4 ;
  END clk_in
  PIN rst_n 
    ANTENNAPARTIALMETALAREA 19.4901 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.140195 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.164 LAYER M3 ; 
    ANTENNAMAXAREACAR 21.2656 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 0.156568 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.492838 LAYER VIA3 ;
  END rst_n
  PIN clk_o1 
    ANTENNADIFFAREA 0.2282 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 2.4283 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.017485 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.114 LAYER M3 ; 
    ANTENNAMAXAREACAR 26.98 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 0.194254 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.444737 LAYER VIA3 ;
  END clk_o1
  PIN clk_o2 
    ANTENNADIFFAREA 0.2282 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 4.6249 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.033175 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.114 LAYER M3 ; 
    ANTENNAMAXAREACAR 46.2485 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 0.331886 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.444737 LAYER VIA3 ;
  END clk_o2
  PIN locked 
    ANTENNADIFFAREA 0.3302 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 0.3591 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002565 LAYER M3 ;
  END locked
END gcd

END LIBRARY
